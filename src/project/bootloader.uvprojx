# Keil uVision project bootloader.uvprojx, settings and files
target bootloader_v4.0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_v40 +hex
  AfterMake: fromelf.exe --bin -o./Obj/bootloader_v40.bin ./Obj/bootloader_v40.axf
  AfterMake: fromelf.exe --i32 -o./Obj/bootloader_v40.hex ./Obj/bootloader_v40.axf
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FWlib\inc;..\CM3;..\app;..\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ../startup/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/SRC/: stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_gpio.c
  group CMSYS
    ../CM3/: core_cm3.c system_stm32f10x.c
  group readme
    ./user/: readme.txt
  group app
    ../app/: flash.c main.c updata.c
  group bsp
    ../bsp/: bsp.c
